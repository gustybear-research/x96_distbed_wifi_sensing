options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_dual_cw_rcs
    output_language: python
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**7
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number delay samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '33'
  states: {}
- name: freq
  id: variable
  parameters:
    value: (-3000000,3000000)
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/float(packet_len)
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: int(packet_len*2)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**21
  states: {}
- name: range_res
  id: variable
  parameters:
    value: (3e8/2/float((freq[1]-freq[0])))
  states: {}
- name: range_time
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_protect
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Find peak protected samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '14250000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Find peak threshold
    orient: Qt.Horizontal
    start: '-500'
    step: '1'
    stop: '100'
    value: '-200'
  states: {}
- name: time_res
  id: variable
  parameters:
    value: packet_len/float(samp_rate)
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: (freq[1]-freq[0])
    push_power: 'False'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'True'
    len_key: '"packet_len"'
    max_freq: '[-300,300]'
    samp_protect: int(samp_protect)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,range_res]'
    interval: '100'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: amplitude
    frequency: freq[0]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_signal_generator_cw_c_0_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: amplitude
    frequency: freq[1]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''TX/RX'''
    antenna_tx: '''TX/RX'''
    args_rx: '''addr=10.10.3.25'''
    args_tx: '''addr=10.10.3.20'''
    center_freq: center_freq
    gain_rx: gain_rx
    gain_tx: gain_tx
    num_delay_samps: int(delay_samp)
    samp_rate: samp_rate
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_1, '0', radar_usrp_echotimer_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', radar_find_max_peak_c_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_add_xx_1, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_signal_generator_cw_c_0_0, '0', blocks_add_xx_1, '1']
- [radar_signal_generator_cw_c_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']

metadata:
  file_format: 1
